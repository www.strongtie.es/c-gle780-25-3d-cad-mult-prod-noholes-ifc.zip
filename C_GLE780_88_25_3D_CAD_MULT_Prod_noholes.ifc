Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-10T15:05:20
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 10 15:05:20 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{8C381CBC-B0C0-44F7-81B0-02CA7B68F8AC}\ifc * Database version: 5507 * Database creation date: Tue Oct 10 15:05:20 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 10 15:05:20 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 10 15:05:20 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Remove Holes\RFA 3D\C_GLE780_88_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Line Pattern: -3000010; Line Weight: 1; Color: 0; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_GLE780_88_25_3D_CAD_MULT_Prod_noholes, C_GLE780_88_25_3D_CAD_MULT_Prod_noholes:C_GLE780_88_25_3D_CAD_MULT_Prod_noholes:136442
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.0062593 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE780/88/2.5
Identity Data - Product Type: Joist hanger; Name: GLE780/88/2.5; Provide Feedback: mailto:EUdrawings@strongtie.com; URL: www.strongtie.eu; ObjectType: GLE780/88/2.5; Manufacturer: Simpson Strong-Tie; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Copyright: ©Simpson Strong-Tie; UniClass Title: Joist hangers; Description: Joist hanger; Model ID: 0287055993771139491214220043920643188221; OmniClass Title: Wood Connectors; OmniClass Number: 23.20.40.11.24.14; UniClass Number: Pr_20_29_31_44; Model: GLE780/88/2.5
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE780/88/2.5; Density: 1.38
Materials and Finishes - Product Material: Galvanised
