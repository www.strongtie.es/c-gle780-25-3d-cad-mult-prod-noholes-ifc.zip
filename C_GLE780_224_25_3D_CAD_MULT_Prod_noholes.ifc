Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-10-10T15:06:01
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 10 15:06:01 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{CA2C44A4-77E9-426C-96BA-743B0AEC115C}\ifc * Database version: 5507 * Database creation date: Tue Oct 10 15:06:01 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 10 15:06:01 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 10 15:06:01 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 2 - 250 Models\Remove Holes\RFA 3D\C_GLE780_224_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Symbol at End 1 Default: no; Line Pattern: -3000010; Symbol at End 2 Default: yes; Line Weight: 1

# IfcBuildingElementProxy: C_GLE780_224_25_3D_CAD_MULT_Prod_noholes, C_GLE780_224_25_3D_CAD_MULT_Prod_noholes:C_GLE780_224_25_3D_CAD_MULT_Prod_noholes:179146
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00624164 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE780/224/2.5
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.38; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE780/224/2.5; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Model: GLE780/224/2.5; URL: www.strongtie.eu; Description: Joist hanger; Product Type: Joist hanger; OmniClass Title: Wood Connectors; UniClass Number: Pr_20_29_31_44; Manufacturer: Simpson Strong-Tie; UniClass Title: Joist hangers; Name: GLE780/224/2.5; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Number: 23.20.40.11.24.14; Model ID: 0114743909655756898093444669497713933578; Provide Feedback: mailto:EUdrawings@strongtie.com; ObjectType: GLE780/224/2.5; Copyright: ©Simpson Strong-Tie
Materials and Finishes - Product Material: Galvanised
